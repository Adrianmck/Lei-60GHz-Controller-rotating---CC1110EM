<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\QUB_BWN_CC1110EM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


