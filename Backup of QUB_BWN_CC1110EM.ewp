# IAR project Backup of QUB_BWN_CC1110EM.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1110.i51
  ICC8051.CCDefines: chip=1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\library\header; ..\..\library\source
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../library/source/: DMAradio.c hal_adc_mgmt.c hal_bui_lcd.c hal_power_clk_mgmt.c Radio.c wdt.c
    ./: QUB_BWN_Ctrl.c
